# Keil uVision project motor_control_stm32g431_tim.uvprojx, settings and files
target motor_control_stm32g431_tim (6190000::V6.19::ARMCLANG)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: motor_control_stm32g431_tim +hex
  BeforeMake: ..\gmp_fac_generate_src.bat
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_NUCLEO_64,USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/BSP/STM32G4xx_Nucleo;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\..\..\..\..\..\csp\stm32;..\..\..\..\..\..\..\gmp_pro;..\..\..\implement\stm32g431;..\..\..\implement\common
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/BSP/STM32G4xx_Nucleo
    ../Drivers/BSP/STM32G4xx_Nucleo/: stm32g4xx_nucleo.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group GMP/SDK
    ../gmp_src/: ctl_component_advance.c ctl_component_continuous.c ctl_component_discrete.c ctl_component_interface.c ctl_component_lebesgue.c ctl_component_protection.c ctl_mc_basic.c ctl_mc_consultant.c ctl_mc_current_loop.c ctl_mc_motion.c ctl_mc_observer.c ctl_nano.c gmp_dev_util.c gmp_ds_list.c gmp_mm_block_memory.c gmp_std_error_code.c gmp_std_port.c stm32_chip_common.c
  group GMP/User
    ../../../implement/common/: ctl_main.c ctl_main.h user_main.c user_main.h
  group GMP/PMSM_Bare_ctrl
    ../../../: pmsm_ctrl.h
    ../../../src/: pmsm_ctrl.c
  group GMP/xplt
    ../../../implement/stm32g431/: ctrl_settings.h xplt.config.h xplt.ctl_interface.h xplt.peripheral.c xplt.peripheral.h
software components: CMSIS:CORE 5.6.0
