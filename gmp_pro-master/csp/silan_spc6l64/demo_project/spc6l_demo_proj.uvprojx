# Keil uVision project spc6l_demo_proj.uvprojx, settings and files
target SPC6L64 (5060750::V5.06 update 6 (build 750)::.\ARMCCV5)
  device: SPC6L64 SILAN
  pack: SILAN.SPC6Lxx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2800) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: spc6l_demo_proj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\gmp_pro;..\..\silan_spc6l64;.\user
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group SPC6L64/Driver
    ./driver_src/: DRV_ACMP.c DRV_Adc.c DRV_BT01.c DRV_Clk.c DRV_Coproc.c DRV_DMA.c DRV_GPIO.c DRV_IAP.c DRV_IRQ.c DRV_OPA.c DRV_PWM.c DRV_SPI.c DRV_Timer.c DRV_Uart1.c DRV_WDT.c MOTOR_Math_func.c
  group GMP/Source
    ./gmp_src/: ctl_component_advance.c ctl_component_continuous.c ctl_component_discrete.c ctl_component_interface.c ctl_component_lebesgue.c ctl_component_protection.c ctl_mc_basic.c ctl_mc_consultant.c ctl_mc_current_loop.c ctl_mc_motion.c ctl_mc_observer.c ctl_nano.c gmp_dev_util.c gmp_ds_list.c gmp_mm_block_memory.c gmp_std_error_code.c gmp_std_port.c spc6l64b_csp.c
  group User
    ./user/: ctl_main.c ctl_main.h ctrl_settings.h user_main.c user_main.h xplt.config.h xplt.ctl_interface.h xplt.peripheral.c xplt.peripheral.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
